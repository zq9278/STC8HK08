# Keil uVision project STC8HK08.uvproj, settings and files
target STC8HK08 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC8HK08 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: lib\Inc;user\Inc;..\..\SoftWare\keil_c51\C51\INC
  group SRC
    src/: main.c
  group LIB/SRC
    lib/src/: STC8G_H_ADC.c STC8G_H_ADC_Isr.c STC8G_H_Delay.c STC8G_H_Exti.c STC8G_H_Exti_Isr.c STC8G_H_GPIO.c STC8G_H_GPIO_Isr.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c STC8G_H_WDT.c STC8G_PWM15bit.c STC8G_PWM15bit_Isr.c STC8H_PWM.c STC8H_PWM_Isr.c STC8H_RTC.c STC8H_RTC_Isr.c
  group USER/SRC
    user/src/: gpio.c Interrupt.c
